# Keil uVision project STM32-DEMO.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\System\sys;..\Hardware\ADCSample;..\System\Timer3;..\Hardware\OLED;..\System\delay;..\Hardware\LCD;..\Hardware\miscport;..\System\HOST_UART;..\Hardware\location;..\Hardware\decadriver;..\Hardware\decaplatform;..\application;..\System\DMA_UART;..\System;..\Hardware\ZLSN7004;..\Hardware\bluetooth;..\Hardware\flash;..\Hardware\DAC;..\Hardware
  asm include: ..\Hardware\MyGPIO;..\System\sys;..\Hardware\ADCSample;..\Hardware\decaplatform
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c
  group application
    ../application/: instance_calib.c instance_common.c dw_main.c instance_tag.c instance_anch.c anchors.c downloadJob.c dangerArea.c trilateration.c smoothAlgorithm.c RTLSClient.c
  group decaplatform
    ../Hardware/decaplatform/: deca_sleep.c deca_spi.c deca_mutex.c deca_range_tables.c
  group Hardware
    ../Hardware/ADCSample/: ADCSample.c
    ../Hardware/miscport/: miscport.c
    ../Hardware/location/: dwmconfig.c
    ../Hardware/flash/: stmflash.c
    ../Hardware/: standby.c
    ../Hardware/DAC/: DACOutput.c
  group decadriver
    ../Hardware/decadriver/: deca_params_init.c deca_device.c
  group System
    ../System/sys/: sys.c
    ../System/Timer3/: timer3.c
    ../System/delay/: delay.c
    ../System/HOST_UART/: host_usart.c
    ../application/: netproto.c
    ../System/DMA_UART/: dma_uart3.c dma_uart2.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
